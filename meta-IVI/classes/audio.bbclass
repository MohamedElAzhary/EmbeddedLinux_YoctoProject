


IMAGE_INSTALL:append = " pavucontrol pulseaudio pulseaudio-module-dbus-protocol pulseaudio-server pulseaudio-module-loopback pulseaudio-module-bluez5-device \
pulseaudio-module-bluez5-discover alsa-utils alsa-plugins packagegroup-tools-bluetooth pulseaudio-module-bluetooth-policy packagegroup-rpi-test rpiplay \
can-utils net-tools gstreamer1.0 iproute2 iputils qtbase-plugins libsocketcan qtquickcontrols2 qtgraphicaleffects qtmultimedia qtserialbus qtquicktimeline \
qtvirtualkeyboard i2c-tools hostapd iptables pulseaudio mpg123 alsa-utils-scripts alsa-ucm-conf alsa-topology-conf alsa-tools alsa-state alsa-lib bluez5 "
