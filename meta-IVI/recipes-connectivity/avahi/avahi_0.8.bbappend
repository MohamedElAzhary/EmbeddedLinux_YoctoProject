PACKAGECONFIG:append = " libdns_sd"
